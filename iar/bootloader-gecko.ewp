# IAR project bootloader-gecko.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG330F256 SiliconLaboratories EFM32LG330F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32LG330F128
  ICCARM.CCIncludePath2: ..\lib\Include; ..\src; ..\src\config_gecko; ..\emlib\inc\; ..\emlib\cputype\EFM32LG\Include; ..\usb\inc\; ..\emlib\cputype\Include; ..\src\wifi\; ..\src\wifi\CC3000HostDriver\; ..\src\wifi\CC3000 Spi\; ..\src\3g
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32G\Include; ..\src; ..\src\config_gecko
  OBJCOPY.OOCOutputFile: bootloader-gecko.bin
  ILINK.IlinkOutputFile: bootloader-gecko.out
  ILINK.IlinkIcfFile: EFM32LG330F256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G200F16
  ICCARM.CCIncludePath2: ..\lib\Include; ..\src; ..\src\config_gecko; ..\emlib\inc\; ..\emlib\cputype\EFM32LG\Include; ..\usb\inc\; ..\emlib\cputype\Include; ..\src\wifi\; ..\src\wifi\CC3000HostDriver\; ..\src\wifi\CC3000 Spi\
  ILINK.IlinkIcfFile: ..\src\bootloader.icf
  group emlib
    ../emlib/src/: em_adc.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_i2c.c em_int.c em_leuart.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_wdog.c
  group McuType
    ../emlib/cputype/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../emlib/cputype/EFM32LG/Source/: system_efm32lg.c
  group Source
    ../src/: ble.c energy_micro_clk_system.c flash.c gpio.c gps.c gsensor.c gsm.c gsmoperate.c lcd_io.c main.c myfunction.c protocol.c queue.c rtc.c spi.c timer_conver.c usart.c usb_user.c
    ../src/wifi/CC3000HostDriver/: evnt_handler.c hci.c nvmem.c
  group Source/3G
    ../src/3g/: ue866_gpio.c ue866_operate.c
  group USB
    ../usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
