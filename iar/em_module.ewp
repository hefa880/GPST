# IAR project em_module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G200F16 EnergyMicro EFM32G200F16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\lib\Include; ..\src; ..\src\config_gecko; ..\emlib\inc\; ..\emlib\cputype\EFM32GG\Include; ..\emlib\cputype\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32G\Include; ..\src; ..\src\config_gecko
  OBJCOPY.OOCOutputFile: bootloader-gecko.bin
  ILINK.IlinkOutputFile: bootloader-gecko.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G200F16.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G200F16
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\src\bootloader.icf
  group emlib
    ../emlib/src/: em_cmu.c em_gpio.c
  group Source
    ../src/: energy_micro_clk_system.c gpio.c main.c startup_efm32.s
